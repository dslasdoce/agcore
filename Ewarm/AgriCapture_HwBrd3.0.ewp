# IAR project AgriCapture_HwBrd3.0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F779BI ST STM32F779BI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F779xx; USE_HAL_DRIVER; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\Include; ..\Drivers; ..\Middleware; ..\Drivers\CMSIS\Include; ..\Drivers\STM32F7xx_HAL_Driver\Include; ..\Drivers\STM32F7xx_HAL_Driver\Include\Legacy; ..\Middleware\FatFs\Include; ..\Middleware\FatFs\Include\Core; ..\Middleware\FatFs\Include\Driver; ..\Include; ..\Include\Ble; ..\Include\Bsp; ..\Include\Bsp\BoardInit; ..\Include\Bsp\Interfaces; ..\Include\Bsp\Interrupts; ..\Include\Cloud; ..\Include\Cloud\CloudComms; ..\Include\Cloud\CloudUtil; ..\Include\Daq; ..\Include\Daq\daqTelem; ..\Include\Daq\daqUtil; ..\Include\Dm; ..\Include\Dm\DmArchive; ..\Include\Dm\DmArchive\SdCard; ..\Include\Dm\DmLogger; ..\Include\Radio; ..\Include\Radio\RdBanner; ..\Include\Utility; ..\Drivers\STM32F7xx_HAL_Driver\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AgriCapture_HwBrd3.0.hex
  ILINK.IlinkOutputFile: AgriCapture_HwBrd3.0.out
  ILINK.IlinkIcfFile: AgriCapture_HwBrd3.0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group Drivers/CMSIS/Source
    ../Drivers/CMSIS/Source/: startup_stm32f779xx.s system_stm32f7xx.c
  group Drivers/STM32F7xxHALDrivers/Source
    ../Drivers/STM32F7xx_HAL_Driver/Source/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Middleware/FatFs/Source/Core
    ../Middleware/FatFs/Source/Core/: diskio.c ff.c ff_gen_drv.c
  group Middleware/FatFs/Source/Driver
    ../Middleware/FatFs/Source/Driver/: sd_diskio.c
  group Source
    ../Source/: bringup_testcodes.c main.c
  group Source/Ble
    ../Source/Ble/: ble.c
  group Source/Bsp/BoardInit
    ../Source/Bsp/BoardInit/: agBoardInit.c bsp_pwm.c gpio.c pexpander.c port.c rtc.c sigpathSetup.c
  group Source/Bsp/Interfaces
    ../Source/Bsp/Interfaces/: i2c.c modbus.c mspSpi.c oneWire.c sdi12.c valve.c
  group Source/Bsp/Interrupts
    ../Source/Bsp/Interrupts/: exceptionHandlers.c extInterrupt.c timerInterrupt.c
  group Source/Cloud
    ../Source/Cloud/: cloud.c
  group Source/Cloud/CloudComms
    ../Source/Cloud/CloudComms/: cell.c wifi.c
  group Source/Cloud/CloudUtil
    ../Source/Cloud/CloudUtil/: api.c http.c parson.c
  group Source/Daq
    ../Source/Daq/: daqProcess.c daqSysStat.c
  group Source/Daq/DaqTelem
    ../Source/Daq/DaqTelem/: daqAdcSpi.c daqDavis.c daqSensInterface.c
  group Source/Daq/DaqUtil
    ../Source/Daq/DaqUtil/: daqPrintUtil.c dataConversion.c equations.c
  group Source/Dm
    ../Source/Dm/: dmInit.c
  group Source/Dm/DmArchive
    ../Source/Dm/DmArchive/: extFlash.c intFlash.c
  group Source/Dm/DmArchive/sdCard
    ../Source/Dm/DmArchive/SdCard/: sdCfgFiles.c sdMain.c sdProcess.c
  group Source/Dm/DmLogger
    ../Source/Dm/DmLogger/: loggerMain.c
  group Source/Radio
    ../Source/Radio/: radio.c tempUnitList.c
  group Source/Radio/RdBanner
    ../Source/Radio/RdBanner/: rdBnrGate.c rdBnrMain.c rdBnrNode.c
  group Source/Utility
    ../Source/Utility/: agdatim.c agps.c agstring.c crc16MB.c delay.c extRTC.c utilCalc.c utilMem.c utilPwrMonitor.c
